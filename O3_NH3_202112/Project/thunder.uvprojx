# Keil uVision project thunder.uvprojx, settings and files
target O3_NH3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thunder
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User\bsp\inc;..\User\bsp;..\User\app\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries;..\User\Network;..\User\Protocol\include;..\User\Protocol\coap_lwm2m;..\User\Protocol\platforms
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../User/app/src/: main.c func.c
    ../User/bsp/src/: menu.c
    ../User/app/inc/: func.h
  group bsp
    ../User/bsp/: bsp.h bsp.c stm32f10x_it.c
    ../User/bsp/src/: bsp_led.c bsp_key.c bsp_i2c_gpio.c bsp_dht22.c bsp_usart3.c bsp_uart_fifo.c bsp_diwen.c bsp_eeprom_24xx.c bsp_hc.c bsp_iocontrol.c bsp_mkey.c bsp_tim_capture.c bsp_timer.c bsp_cpu_rtc.c bsp_iwdg.c bsp_adc.c
  group lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_iwdg.c
    ../Libraries/: at_cmd.c fifo.c memb.c ringbuf.c
  group CMSIS
    ../User/bsp/: system_stm32f10x.c
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group platform
    ../User/Protocol/platforms/: environment.c memory.c socket.c utils.c
  group COAP
    ../User/Protocol/coap_lwm2m/: nbiot.c nblist.c node.c observe.c registraction.c transaction.c
  group NETWORK
    ../User/Network/: M5310.c
  group doc
    ../Doc/: ReadMe.txt
