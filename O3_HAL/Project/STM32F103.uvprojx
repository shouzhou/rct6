# Keil uVision project STM32F103.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\User\Bsp\inc;..\User\Bsp;..\User\segger;..\User;..\Lib\CMSIS\Device\ST\STM32F1xx\Include;..\Lib\CMSIS\Include;..\Lib\STM32F1xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group Bsp
    ../User/Bsp/: bsp.h bsp.c stm32f1xx_it.c
    ../User/Bsp/src/: bsp_led.c bsp_timer.c bsp_key.c bsp_uart_fifo.c
  group MDK-ARM
    ../Lib/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group HAL_Driver
    ../User/Bsp/: stm32f1xx_hal_conf.h
    ../Lib/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c
  group CMSIS
    ../Lib/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group SEGGER/HardFault
    ../User/segger/: SEGGER_HardFaultHandler.c HardFaultHandler.S
  group Doc
    ../Doc/: readme.txt
