# Keil uVision project 小小晟_PLC_PRO.uvprojx, settings and files
target XXS_FX2N_PLC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: XXS_FX2N_V3.8.1.201610 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\inc;..\CMSIS;..\users;..\Libraries\src;..\Libraries\sys
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/: startup_stm32f10x_md_vl.s
  group FWLB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group PLC
    ../users/: main.c ladder.c PLC_timer.c NVIC_interrupt.c PLC_IO.C Pulse.c PLC_Other.C
  group COMM
    ../users/: PLC_Com.c Modbus_485.c
  group RTC
    ../users/: RTC.C
  group AD_DA
    ../users/: DAC.C ADC.C
  group DOC
    ../users/: 程序说明.h
