# Keil uVision project thunder.uvprojx, settings and files
target thunder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thunder
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User\bsp\inc;..\User\bsp;..\User\app\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\User\FatFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../User/app/src/: main.c demo_sd_Fatfs.c
  group bsp
    ../User/bsp/: bsp.c bsp_msg.c stm32f10x_assert.c stm32f10x_it.c
    ../User/bsp/src/: bsp_led.c bsp_key.c bsp_uart_fifo.c bsp_timer.c bsp_sdio_sd.c bsp_adc.c bsp_exti.c
  group lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c
  group CMSIS
    ../User/bsp/: system_stm32f10x.c
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group FatFS
    ../User/FatFS/src/: ff.c diskio.c
    ../User/FatFS/src/option/: cc936.c
