# Keil uVision project thunder.uvprojx, settings and files
target thunder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thunder +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD LITTLE_ENDIAN
  c include: ..\User\bsp\inc;..\User\bsp;..\User\app\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../User/app/src/: main.c demo_i2c_eeprom.c
  group bsp
    ../User/bsp/: bsp.c bsp_msg.c stm32f10x_assert.c stm32f10x_it.c
    ../User/bsp/src/: bsp_led.c bsp_key.c bsp_uart_fifo.c bsp_timer.c bsp_diwen.c bsp_hc.c bsp_tim_capture.c bsp_i2c_gpio.c bsp_eeprom_24xx.c bsp_iocontrol.c bsp_dht22.c bsp_mkey.c
  group lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../User/bsp/: system_stm32f10x.c
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
